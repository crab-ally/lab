Commit message: tcp origin를 mjcf와 동일하게 수정

File: cobot_pnp_safety/urdf/panda.urdf (robot description, URDF)
Before this commit: robot panda, 13 links, 12 joints
Joints:
- joint tcp_joint: origin xyz=0 0 0.1034 rpy=0 0 0 -> xyz=0 0 0.11 rpy=0 0 0
